## workspaces/lld/source/linux_bbb_4.14/drivers/char/My_C_Dev/Kconfig
```kconfig
menu "Irshad's custom module"
config CUSTOM_HELLO
	tristate "Hello world module support"
	default n
endmenu
```
